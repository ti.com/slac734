# Allegro board DAC38RF8XEVM.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TESTMODE: length 64.4
  L3_PWR w0.127: v1(26.19,41.73) 22.45,41.73 19.68,44.5 19.68,53.72 22.89,56.92 28.5,56.92 31.92,60.34 31.92,63.84 33.43,65.35 33.43,66.83 33.81,67.21 39.95,67.21 TP10.1
  L4_SIG w0.102: 34.89,31.73 35.17,31.45 35.17,30.24 34.79,29.86 v1(34.79,29.81)
  L4_SIG w0.127: v1(26.19,41.73) 26.19,41.35 26.4,41.13 26.3,41.03 26.3,40.66 26.56,40.4 26.93,40.4 27.03,40.5 27.82,39.71 28.25,39.71 28.51,39.45 28.51,39.05 29.45,38.11 29.95,38.11 30.21,37.85 30.21,37.38 31.21,36.38 31.56,36.38 31.83,36.12 31.83,35.59 32.44,34.98 32.44,34.19 34.89,31.73
TXENABLE: length 70
  L4_SIG w0.127: JP2.2 89.71,47.88 85.19,43.36 85.19,41 83.18,38.99 83.18,38.06 82.38,37.25 82.01,37.25 81.91,37.35 73.62,37.35 72.73,38.24 72.36,38.24 72.21,38.09 62.24,38.09 62.21,38.11 56.98,38.11 56.54,38.56 42.32,38.56 41.28,37.51 v1(41.28,37.03)
  BOTTOM w0.102: v1(32.39,29.81) 32.39,29.82 32.8,30.24 34.14,30.24 34.36,30.46 34.36,30.76 35.34,31.73
  BOTTOM w0.127: v1(41.28,37.03) 39.18,34.94 38.54,34.94 35.34,31.73
USB_DM: length 23.6
  BOTTOM w0.229: U4.7 33.12,54.15 31.72,54.15 31.58,54.29 31,54.29 28.11,57.19 16.25,57.19 13.98,54.91 13.31,54.91 C77.1 12.95,54.56 R65.2
USB_DP: length 23.6
  BOTTOM w0.229: R66.2 12.95,55.68 13.34,55.3 13.82,55.3 16.09,57.57 28.26,57.57 31.16,54.67 31.74,54.67 31.88,54.53 33.13,54.53 U4.8
USB_EECLK: length 6.5
  TOP w0.127: R72.1 36.55,48.64 36.07,49.12 36.07,51.38 v1(36.06,51.39) 36.28,51.61 U5.2
  BOTTOM w0.127: U4.62 v1(36.06,51.39)
USB_EECS: length 7.7
  TOP w0.127: R71.1 35.53,48.59 35.53,50.95 v1(35.38,51.1) 35.38,51.44 35.63,51.68 U5.1
  BOTTOM w0.127: v1(35.38,51.1) 35.56,50.93 U4.63
USB_REF: length 3.3
  TOP w0.127: R68.1 v1(34.59,54.2)
  BOTTOM w0.127: v1(34.59,54.2) 34.59,53.82 34.36,53.59 U4.6
USB_RST: length 3.1
  BOTTOM w0.305: U4.14 31.08,57.59 R69.2
VAR: length 2.8
  TOP w0.381: U12.5 80.98,57.89 81.18,58.09
  BOTTOM w0.381: U35.4 86.75,62.6 86.89,62.46 86.89,61.42 v1(87.07,61.24)
  vias: v1(74.75,57.89) v1(75.32,57.89) v1(77.67,59.2) v1(77.85,60.66) v1(77.88,61.42) v1(78.32,59.2) v1(79.1,58.88) v1(79.35,60.66) v1(79.4,61.42) v1(80.92,61.39) v1(80.9,60.66) v1(86.11,41.99) v1(86.13,41.22) v1(87.07,60.5) v1(87.07,41.99) v1(87.07,41.22) v1(87.96,61.21) v1(87.99,60.48)
VDIG: length 2
  TOP w0.305: 66.12,60.58 65.72,60.97 U31.16
  BOTTOM w0.508: v1(67.82,65.43) v1(66.73,65.43)
  vias: v1(68.07,60.96) v1(69.04,57.61) v1(69.44,59.79) v1(69.6,60.95) v1(69.82,56.92) v1(70.05,59.03) v1(70.59,58.22) v1(70.66,56.49) v1(71.04,60.91)
VSENSE: length 41.7
  L4_SIG w0.102: v1(33.99,25.01) 33.61,24.63 33.61,23.19 33.41,22.99 33.03,22.99 32.81,22.77 32.81,22.39 32.64,22.23 27.43,22.23 27.28,22.37
  L4_SIG w0.127: 27.28,22.37 26.35,23.31 26.14,23.31 25.67,23.79 25.67,30.87 24.28,32.26 24.28,35.68 18.9,41.06 18.87,41.06 14.23,45.69 11.08,45.69 v1(10.56,46.22)
Y2_N: length 6.2
  BOTTOM w0.381: R52.1 124.18,57.38 R53.1
  BOTTOM w0.483: R53.1 124.66,57.35 125.2,56.82 126.42,56.82 127,57.4 Y1.4
Y2_P: length 6.4
  BOTTOM w0.381: 124.21,58.17 124.18,58.14 R44.1
  BOTTOM w0.483: Y1.5 128.75,59.59 125.93,59.59 124.51,58.17 124.21,58.17
YO2_N: length 0.8
  BOTTOM w0.381: C49.1 R52.2
YO2_P: length 0.8
  BOTTOM w0.381: C44.1 R44.2
N16791764: length 5.8
  BOTTOM w0.508: J16.1 7.19,55.63 10.46,52.35 R64.2
N16791900: length 3.3
  TOP w0.508: C68.1 31.17,52.76 v1(31.19,52.78)
  BOTTOM w0.305: U4.4 31.38,52.59 v1(31.19,52.78)
  vias: v1(27.97,52.78) v1(28.07,53.87) v1(28.91,53.11)
N16791904: length 3.5
  TOP w0.508: C66.1 31.14,55.85 v1(31.19,55.8)
  BOTTOM w0.305: U4.9 32.08,55.09 31.37,55.8 v1(31.19,55.8)
  vias: v1(28.07,56.41) v1(28.02,55.19) v1(28.96,55.22)
N16792068: length 1
  BOTTOM w0.305: R67.2 R69.1
  vias: v1(29.29,58.55)
N16792392: length 3.1
  TOP w0.127: R74.2 37.87,50.04 R73.1 37.58,51.22 U5.4
N16935208: length 19.8
  TOP w0.127: v1(37.57,61.8) 37.37,61.8 37.05,61.48 37.05,61.48 36.98,61.42 35.89,61.42 33.53,59.05 20.9,59.05 R178.2
  BOTTOM w0.127: U4.22 v1(37.57,61.8)
N16935212: length 18.2
  TOP w0.127: R177.2 21.59,59.54 22.56,60.5 33.88,60.5 35.71,62.33 36.45,62.33 v1(36.88,61.9)
  BOTTOM w0.127: U4.21 37.06,61.72 v1(36.88,61.9)
N16935236: length 10.5
  BOTTOM w0.127: v1(24.99,59.54) 25.48,60.02 33.88,60.02 34.33,60.46 U4.17
N16935238: length 15.7
  TOP w0.127: R176.2 23.24,60.07 34.01,60.07 35.81,61.87 v1(36.04,61.87)
  BOTTOM w0.127: U4.19 v1(36.04,61.87)
N16935240: length 7.4
  BOTTOM w0.127: v1(26.14,59.54) 28.4,59.54 28.87,59.07 31.25,59.07 31.73,58.59 U4.16
N16935242: length 14
  BOTTOM w0.127: v1(23.85,59.54) 24.74,60.43 33.35,60.43 34.8,61.87 35.33,61.87 35.56,61.64 U4.18
N17033323: length 2.3
  BOTTOM w0.305: R63.1 24.56,54.25 FB17.1
N17033325:
  vias: v1(23.5,55.27)
N17488920:
  vias: v1(138.58,35.53)
N17488936: length 18.5
  BOTTOM w0.127: R80.1 139.42,30.05 139.42,30.53 140.51,31.62 140.51,35.46 141.86,36.8
  BOTTOM w0.165: J20.C18 150.47,36.8 141.86,36.8
N17488940:
  vias: v1(138.58,32.84)
N17488944: length 16
  BOTTOM w0.127: R83.1 139.93,33.15 139.93,36.02 141.86,37.95
  BOTTOM w0.165: 141.86,37.95 142.11,38.2 149.28,38.2 149.86,37.62 J20.D18
N17488958: length 14.6
  BOTTOM w0.127: R82.1 139.42,35.36 139.42,36.96 141.86,39.4
  BOTTOM w0.165: J20.D17 149.86,38.86 149.25,39.47 141.94,39.47 141.86,39.4
N17488997:
  vias: v1(137.29,36.02)
N17489014:
  vias: v1(138.56,30.2)
N17489769: length 0.8
  BOTTOM w0.127: v1(135.53,35.99) R81.1
N17489787: length 0.8
  BOTTOM w0.127: v1(135.53,30.66) R79.1
N17489827: length 0.8
  BOTTOM w0.127: v1(135.53,33.32) R84.1
N17512943: length 6.8
  BOTTOM w0.102: 27.28,22.99 28.23,22.99 28.54,22.99 28.55,22.99 28.65,22.99 28.81,23.14 28.81,23.69 28.95,23.84 29.34,23.84 29.72,24.21 v1(29.99,24.21)
  BOTTOM w0.127: R12.1 25.68,22.45 26.21,22.99 27.28,22.99
N17771557: length 24.6
  L6_PWR_SIG w0.127: v1(60.55,36.07) 66,36.07 77.75,47.82 v1(77.75,50.32)
  vias: v1(48.11,47.12) v1(48.87,47.5) v1(55.98,46.61) v1(55.98,45.62) v1(56.74,46.58) v1(56.74,45.59) v1(59.79,36.07) v1(59.79,35.08) v1(60.53,35.1) v1(70.18,45.92) v1(70.18,45.06) v1(70.18,44.2) v1(71.04,45.92) v1(71.04,45.06) v1(71.04,44.2) v1(71.91,45.92) v1(71.91,45.06) v1(71.91,44.2)
N17785139: length 2.2
  TOP w0.305: U19.5 53.62,50.57 v1(53.85,50.57)
  BOTTOM w0.305: R126.2 v1(53.85,50.57)
N17785180: length 3.4
  TOP w0.305: C303.1 v1(55.5,48.84) 55.5,49.23 55.19,49.53 54.08,49.53 53.76,49.21 U19.4
  vias: v1(35.84,46.05) v1(35.84,45.24) v1(36.4,46.05) v1(36.4,45.24) v1(54.48,48.84) v1(54.48,48.16) v1(55.47,48.16)
N17787232: length 1.6
  TOP w0.508: v1(99.06,55.12) 99.69,55.12 100.2,54.61 v1(100.2,54.38)
  vias: v1(100.63,56.16) v1(100.58,55.37) v1(100.71,53.72) v1(100.84,54.36) v1(101.6,53.34) v1(102.46,52.96) v1(103.53,52.98)
N17787234: length 1.5
  BOTTOM w0.305: v1(93.47,53.16) 94.99,53.16 U21.14
N17787274: length 1.7
  TOP w0.305: v1(94.26,51.85) 95.16,51.85 R129.2
  BOTTOM w0.305: U21.12 v1(94.26,51.85)
N17787303: length 0.5
  BOTTOM w0.305: v1(95.2,50.77) 95.2,51.01 U21.11
N17787374: length 1.5
  TOP w0.305: v1(96.31,49.03) 96.31,49.63 R131.2
  BOTTOM w0.305: U21.10 v1(96.31,49.03)
N17829143:
  vias: v1(44.25,63.09)
N17906763: length 7.5
  TOP w0.483: R148.1 118.34,40.13 120.47,38 J8.1
N17929635: length 1.7
  TOP w0.381: T1.6 28.86,18.14 29.12,18.4 C333.1
N17930246: length 2.2
  TOP w0.483: C1.2 29.17,14.44 arc(29.41,14.76) 29.54,15.14 arc(29.56,15.27) 29.57,15.4 T1.2
N17930866: length 1.7
  TOP w0.381: C334.1 29.94,18.34 30.28,18.01 T1.4
N17940319: length 2.8
  BOTTOM w0.483: L9.2 18.5,17.45 C332.2 18.48,18.6 v1(18.48,18.6)
N17940351: length 2.3
  BOTTOM w0.483: C330.2 16.35,18.6 v1(16.32,18.58) 15.31,18.58 C327.1
N17971041: length 6.3
  TOP w0.483: R238.1 16.02,19.83 v1(15.88,19.69) ; C329.1 15.68,19.74 T5.3
N18050278:
  vias: v2(113.64,55.09)
N18051729: length 4.2
  BOTTOM w0.127: U4.38 45.65,56.09 45.82,56.26 45.82,57.91 v1(46.61,58.7)
N18051775: length 3.7
  BOTTOM w0.127: v1(46.61,57.56) 46.15,57.1 46.15,55.96 45.78,55.59 U4.39
N18051825: length 3
  BOTTOM w0.127: v1(46.61,56.41) 46.53,56.34 46.53,55.83 45.79,55.09 U4.40
N18051839: length 2.5
  BOTTOM w0.127: v1(46.61,55.27) 45.93,54.59 U4.41
N18096853: length 27.4
  L4_SIG w0.127: v1(50.3,59.78) 50.3,61.12 49.31,62.12 47.66,62.12 47.24,61.7 42.75,61.7 41.35,60.3 27.89,60.3 26.14,58.55 v1(26.14,58.52)
N18096873: length 27.3
  L4_SIG w0.127: v1(24.99,58.52) 24.99,58.32 25.44,57.87 27.72,57.87 28.84,58.99 29.34,58.99 29.91,59.55 39.25,59.55 39.39,59.41 41.45,59.41 43.24,61.2 44.72,61.2 46.28,59.64 48.7,59.64 v2(49.43,58.91)
N18096893: length 28.9
  L4_SIG w0.127: v1(23.85,58.52) 24.97,57.4 29.06,57.4 30.19,58.53 34.75,58.53 35.01,58.27 35.01,57.38 35.44,56.95 40.36,56.95 40.56,57.14 42.01,57.14 44.01,59.14 48.69,59.14 v2(49.43,58.41)
N18096913: length 28.9
  L4_SIG w0.127: v2(49.43,57.91) 49.34,58 45.33,58 43.31,55.98 35.06,55.98 34.72,55.64 31.98,55.64 31.25,56.38 29.02,56.38 28.5,56.9 24.33,56.9 v1(22.71,58.52)
N18119227: length 22.3
  TOP w0.483: J24.1 106.55,35.03 104.62,36.96 104.62,49.45 105.33,50.16 106.73,50.16 107.31,49.58 C365.2
N18119976: length 14.5
  TOP w0.483: J25.1 129.24,48.46 121.16,56.54 v1(121.16,56.64)
N18127566: length 2.3
  BOTTOM w0.127: U29.15 48.92,57.41 v1(47.62,58.7)
N18127584: length 2.1
  BOTTOM w0.127: U29.14 48.27,56.91 v1(47.62,57.56)
N18127610: length 1.8
  BOTTOM w0.127: v1(47.62,56.41) 47.63,56.41 U29.13
N18127628: length 2.1
  BOTTOM w0.127: U29.12 48.26,55.91 v1(47.62,55.27)
N18263954: length 15.7
  TOP w0.483: C370.1 26.24,11.52 arc(22.48,9.01) 18.06,8.13 R242.1 14.74,8.14 R213.1
N18264001: length 2.2
  TOP w0.483: R210.2 10.6,8.11 R212.1 9.52,8.1 R211.1
N18264055: length 1
  TOP w0.483: R212.2 R214.1
N18273767: length 1
  TOP w0.483: R213.2 12.65,8.14 R210.1
N18273790: length 1.1
  TOP w0.483: R211.2 7.42,8.09 R215.1
N18276385: length 40.9
  TOP w0.229: v1(83.31,41.76) 83.49,41.94 84.21,41.94 87.4,45.13 87.4,53.44 96.39,62.43 103.73,62.43 106.88,59.28 107.85,59.28 C372.1
  BOTTOM w0.229: U30.11 83.13,41.94 v1(83.31,41.76)
N18276388: length 40.9
  TOP w0.229: v1(83.31,42.6) 83.59,42.32 84.05,42.32 87.02,45.29 87.02,53.6 96.24,62.81 103.89,62.81 107.04,59.66 107.77,59.66 C371.1
  BOTTOM w0.229: v1(83.31,42.6) 83.15,42.44 U30.10
N18284547: length 1.5
  BOTTOM w0.305: U30.2 77.32,41.94 C378.2
N18304202:
  vias: v1(88.14,42.47) v1(88.16,41.53) v1(89.15,42.47) v1(89.18,41.53) v1(90.04,42.47) v1(90.07,41.53) v1(91.06,42.47) v1(91.08,41.53) v1(93.12,41.5)
N18304279: length 2.2
  BOTTOM w0.483: R224.2 92.25,37.59 R225.1 C392.1
  vias: v1(92.2,38.6)
N18304291:
  vias: v1(92.2,41.51)
N18304307: length 1.1
  TOP w0.381: U34.2 91.55,38 v1(91.19,37.64)
  vias: v1(89.36,38.61) v1(89.33,37.62) v1(90.35,37.62) v1(90.37,38.61) v1(91.21,38.63)
N18314120: length 14.5
  BOTTOM w0.305: 77.8,53.42 75.44,53.42 73.33,55.52 73.33,59.87 73.91,60.45 73.91,61.62 74.4,62.1 76.2,62.1 v1(76.45,61.85)
  vias: v1(77.9,54.1) v1(78.41,53.26) v1(78.97,54.1) v1(79.2,52.4) v1(79.22,51.23) v1(79.24,50.01) v1(79.25,48.67) v1(79.53,53.24) v1(80.28,55.29)
N18315082: length 2.5
  BOTTOM w0.305: U35.3 87.96,63.1 R228.1 v1(87.96,62.08)
N18315084: length 11.8
  BOTTOM w0.305: 82.8,63.35 79.4,63.68 L5.1 ; 82.8,63.35 81.99,63.35 ; 82.8,63.35 v2(83.57,63.35) v2(84.2,63.35) U35.6 ; L5.1 81.66,63.35 81.99,63.35 ; L5.1 79.4,63.22 81.99,63.35
  vias: v1(77.9,63.86) v1(78.89,63.86) v1(79.91,63.86) v1(80.92,63.88) v2(84.84,63.35) v2(85.47,63.35)
N18332054: length 2.2
  BOTTOM w0.483: C401.2 16.23,37.04 v1(16.21,37.01) 15.22,37.01 v1(15.14,36.94)
N18332084: length 8.1
  TOP w0.483: R248.2 T7.3 15.25,38.23 v1(15.23,38.26) 14.93,38.26 C399.1
N18332340: length 2.8
  BOTTOM w0.483: L10.2 19.88,35.9 18.34,35.9 C404.2 18.34,37.03 v1(18.34,37.04)
N18332593: length 4.3
  TOP w0.305: v1(78.82,41) v1(78.82,43.38) 78.82,43.43 v1(79.17,43.79)
  BOTTOM w0.305: U30.1 v1(78.82,41) ; U30.5 v1(79.17,43.79) ; U30.4 v1(78.82,43.38)
N18332678: length 5.7
  TOP w0.127: R232.1 140.77,38.13 143.74,38.13 144.22,37.64 144.22,36.75 v3(144.78,36.2)
N18332757: length 3.9
  BOTTOM w0.127: U4.23 38.06,61.84 39.17,62.94 v1(40.08,62.94)
N18336017: length 2.8
  TOP w0.229: U1.A7 31.8,22.4 31.8,20.95 R267.2 31.65,20.04 C438.1
N18336019: length 2.8
  TOP w0.229: U1.A6 32.18,22.41 32.18,20.98 R267.1 32.36,20.04 C439.1
N18340991: length 6.1
  TOP w0.483: C407.2 R280.2 47.17,10.21 J26.1
N18368981: length 8.1
  TOP w0.483: R241.2 15.75,35.71 T7.1 14.99,35.69 10.46,31.17 C413.1
N18431978: length 6.2
  TOP w0.762: JP10.2 83.62,56.57 FB40.3
  BOTTOM w0.762: C420.1 83.11,56.57 JP10.2
  vias: v1(82.4,56.97) v1(83.01,57.33)
N18450019: length 1.5
  BOTTOM w0.127: J11.9 97.94,47.22 R244.2
N18476239: length 4
  BOTTOM w1.016: JP3.1 125.4,62.48 Y1.6
N18477216: length 2.9
  TOP w0.305: U12.16 76.37,53.54 75.77,52.93 R116.1 R115.1
N18478341: length 1.9
  TOP w0.305: U12.9 77.02,60.26 R252.2
N18509121: length 1.5
  TOP w0.305: U31.7 64.72,65.77 C385.2
N18509124: length 1.6
  TOP w0.305: C385.1 64.22,65.54 U31.8
N18509909:
  vias: v1(63.37,63.73)
N18510430: length 2.7
  TOP w0.305: R298.1 65.72,65.65 U31.5
  BOTTOM w0.305: R221.2 65.71,64.47 v1(65.79,64.39) 65.76,64.36 R222.1
N18510599: length 16.4
  TOP w0.305: L3.1 U31.1 66.57,62.42 ; L3.1 66.77,62.42 ; L3.1 67.97,63.53 66.77,62.42 ; L3.1 67.44,62.66 U31.2 66.57,62.42 ; L3.1 67.97,63.14 66.77,62.42 ; 66.77,62.42 66.57,62.42
N18511967: length 1.6
  TOP w0.305: U31.4 66.81,63.64 v1(67.13,63.96)
  BOTTOM w0.305: R226.1 67.36,63.96 v1(67.13,63.96)
N18526029: length 1.7
  TOP w0.305: U37.17 U37.16 U37.15
  vias: v1(65.96,54.31) v1(65.94,53.57) v1(66.7,54.31) v1(66.67,53.57) v1(67.44,54.28) v1(67.41,53.54)
N18526063: length 6.4
  TOP w0.305: JP8.2 68.17,50.34 68.17,52.07 67.69,52.55 v1(67.34,52.55) 67.24,52.65 U37.14
N18526106: length 3
  TOP w0.305: 63.27,53.67 63.43,53.83 U37.19 63.43,54.32 63.3,54.46 ; v2(62.26,53.16) 62.1,53.16 ; 62.1,53.16 v2(61.82,53.16) 61.44,53.16 61.37,53.24 ; 62.1,53.16 U37.20
N18526174: length 2.5
  TOP w0.305: R256.1 R254.2 60.76,52.17 v2(61.85,52.17)
  vias: v2(62.23,52.17)
N18526182: length 2.6
  TOP w0.305: R255.2 61.16,50.77 61.16,51.44 61.37,51.65 U37.4
N18554997:
  vias: v1(38.33,63.68)
N18555017:
  vias: v1(27.18,62) v1(27.76,61.19) v1(28.32,61.98) v1(29.06,61.19) v1(29.72,62) v1(30.58,61.98) v1(30.58,61.11) v1(31.47,63.04) v1(31.47,61.98) v1(31.47,61.14) v1(32.36,61.98) v1(32.36,61.14) v1(32.49,63.04) v1(33.25,61.9) v1(33.38,63.04)
N18555159:
  vias: v1(26.01,61.98)
N18592420: length 2.1
  TOP w0.483: C413.2 R263.1 R274.2
N18592542: length 2.2
  TOP w0.483: R273.2 8.18,42.88 R268.1 9.27,42.85 C399.2
N18601933: length 2.1
  TOP w0.483: C329.2 R265.1 R272.2
N18620813: length 2
  TOP w0.483: T8.3 44.63,10.85 45.01,10.46 C407.1
N18681043: length 12.7
  TOP w0.229: T8.4 39.93,10.85 38.84,11.94 38.33,11.94 31.8,18.47 31.8,19.12 C438.2
N18681093: length 12.7
  TOP w0.229: T8.6 39.9,13.39 38.84,12.32 38.49,12.32 38.08,12.72 38.08,13.23 37.85,13.46 37.35,13.46 33.32,17.48 33.32,18.05 33.1,18.28 32.53,18.28 32.18,18.62 32.18,19.1 C439.2
N18682404: length 0.3
  TOP w0.305: v2(114.15,55.12) 114.17,55.09 C443.1
N18687770: length 1.7
  TOP w0.305: C440.2 66.88,51.77 66.5,52.15 U37.13
N18691780: length 1.9
  TOP w0.305: U19.7 52.18,52.18 C307.1
N18691785: length 1.9
  TOP w0.305: C307.2 51.68,52.16 U19.8
N18692860: length 1.8
  TOP w0.305: C442.1 52.68,47.98 U19.3
N18693421: length 14.2
  TOP w0.305: JP9.2 59.66,61.29 55.98,57.61 55.98,54.97 53.82,52.81 R285.2 52.68,51.43 U19.6
N18712409: length 1.9
  TOP w0.152: R286.2 61.4,52.65 U37.2
N18715563: length 0.8
  TOP w0.305: R283.1 115.11,54.38 C443.2
N18716152: length 2.4
  BOTTOM w0.127: U4.43 46.07,53.59 v1(46.61,54.13)
N18716161: length 2.2
  BOTTOM w0.127: U4.44 46.5,53.09 v1(46.61,52.98)
N18716170: length 2.5
  BOTTOM w0.127: U4.45 45.86,52.59 v1(46.61,51.84)
N18716191: length 4.5
  BOTTOM w0.127: v1(48.36,50.7) 47.83,51.23 46.48,51.23 45.63,52.09 U4.46
N18721299:
  vias: v1(48.11,45.64) v1(48.92,45.09)
N18721339:
  vias: v1(38.96,44.86) v1(39.52,45.44)
N18721381:
  vias: v1(43.61,45.62) v1(44.42,45.06)
N18721471:
  vias: v1(57.56,35.97) v1(57.56,35.15) v1(58.6,35.97) v1(58.6,35.15)
N18728685:
  vias: v1(33.76,46.02) v1(34.37,45.39)
N18728712:
  vias: v1(88.98,32.51) v1(88.98,31.88) v1(89.56,32.18) v1(90.09,32.49) v1(90.09,31.88)
N18728940:
  vias: v1(84.81,32.64) v1(84.84,31.95) v1(85.39,32.33) v1(85.98,32.66) v1(85.98,32)
N18728990:
  vias: v1(80.9,32.61) v1(80.9,32.05) v1(81.46,32.33) v1(82.02,32.61) v1(82.02,32.08)
N18729042:
  vias: v1(61.7,34.77) v1(61.72,34.06) v1(62.71,34.75) v1(62.71,34.06)
N18729096:
  vias: v1(92.96,32.44) v1(92.94,31.85) v1(93.5,32.16) v1(94.03,32.44) v1(94.06,31.85)
N18729152:
  vias: v1(101.55,31.78) v1(101.6,32.44) v1(102.16,32.11) v1(102.72,32.44) v1(102.72,31.8)
N18760111: length 0.7
  BOTTOM w0.305: v2(63.42,50.44) 63.55,50.32 R317.2 63.5,49.94 v2(63.42,49.94)
N18760140: length 1.1
  BOTTOM w0.305: v2(62.92,50.42) 62.84,50.42 62.53,50.11 R318.2 62.59,49.94 v2(62.94,49.94)
N18760186: length 0.4
  BOTTOM w0.305: R319.2 62.18,51.1 v2(62.23,51.16)
  vias: v2(61.72,51.16)
N18804219: length 0.4
  BOTTOM w0.305: C447.2 75.07,55.08 v1(75.07,55.29)
N18805050: length 2.2
  TOP w0.305: R320.2 R321.2 77.75,52.35 R115.2
N18858975: length 33.8
  BOTTOM w0.229: v2(28.41,19.71) 29.11,19.71 29.34,19.94 29.34,20.26 28.9,20.7 28.22,20.7 27.81,20.29 27.81,20.01 27.98,19.84 27.98,19.56 27.78,19.35 27.5,19.35 27.33,19.52 27.03,19.52 26.44,18.93 26.44,14.66 22.45,10.66 10.9,10.66 8.16,7.92 8.16,7.24 8.82,6.58 v1(9.7,6.58)
N18859137: length 3.5
  TOP w0.483: R323.2 9.7,2.03
N18870035: length 1.2
  BOTTOM w0.305: C448.1 108.16,50.52 U2.25
N18870037: length 0.8
  BOTTOM w0.305: C448.2 R329.1
N18893766: length 33.8
  BOTTOM w0.229: v2(30.65,19.71) 29.95,19.71 29.72,19.94 29.72,20.42 29.06,21.08 28.05,21.08 26.06,19.09 26.06,14.81 22.29,11.04 10.75,11.04 7.62,7.92 7.14,7.92 v1(6.1,8.96)
N19080738: length 9.6
  TOP w0.432: JP3.2 126.05,64.38 ; JP3.2 124.29,64.38 ; JP3.2 124.29,66.13 ; JP3.2 125.17,64.08 ; JP3.2 126.34,65.25 ; JP3.2 126.05,66.13 ; JP3.2 124,65.25 ; JP3.2 125.17,66.42
N19081029:
  vias: v1(134.16,59.21)
N19083254: length 45.2
  L6_PWR_SIG w0.127: v1(129.54,22.35) 128.35,23.55 127.58,23.55 124.89,26.24 124.89,32.82 125.27,33.2 125.27,37.77 122.73,40.31 122.23,40.31 116.48,46.05 111,46.05 109.83,47.22 109.83,51.44 v1(108.15,53.11)
  BOTTOM w0.127: U2.31 108.56,53.52 v1(108.15,53.11)
N19083268: length 32.1
  L6_PWR_SIG w0.127: v1(129.57,30.21) 128.99,30.78 128.99,36.29 128.55,36.73 128.55,37.79 128.41,37.93 128.41,39 128.84,39.43 128.84,43.24 126.39,45.69 126,45.69 123.81,47.89 123.79,47.89 123.53,48.15 123.53,48.16 122.38,49.31 122.37,49.31 122.11,49.57 122.11,49.59 118.92,52.77 v1(118.92,55.47)
  BOTTOM w0.127: v1(118.92,55.47) 117.86,55.47 117.65,55.26 U2.48
N19083286: length 28.9
  L6_PWR_SIG w0.127: v1(119.35,48.64) 119.35,48.08 120.95,46.48 120.95,45.9 122.38,44.48 122.38,42.79 125.83,39.33 125.83,32.82 126.01,32.64 126.01,28.38 v1(129.44,24.95)
  BOTTOM w0.127: U2.59 118.98,49.02 v1(119.35,48.64)
N19083328: length 27.2
  L6_PWR_SIG w0.127: v1(129.54,27.56) 127.52,29.59 127.52,36.26 127.62,36.36 127.62,37.2 127.08,37.74 127.08,39.98 122.89,44.17 122.89,46.05 119.42,49.52 v1(119.32,49.52)
  BOTTOM w0.127: U2.58 v1(119.32,49.52)
N19083344: length 2.4
  TOP w0.508: v1(112.11,44.64) 111.79,44.96 C61.1
  BOTTOM w0.305: v1(112.11,44.64) 112.11,45.65 U2.12
N19083346: length 1.5
  TOP w0.508: C62.1 112.64,45.33 v1(112.65,44.98)
  BOTTOM w0.305: U2.11 v1(112.65,44.98)
N19083364: length 4.4
  TOP w0.305: v1(111.64,55.61) 111.64,54.73 C53.2
  BOTTOM w0.305: v1(112.7,44.09) 113.18,44.58 113.18,45.2 113.14,45.24 U2.10 ; U2.33 110.14,55.57 v1(110.03,55.68) ; U2.36 v1(111.64,55.61)
  vias: v1(110.08,54.86)
N19083444: length 2.3
  TOP w0.483: v1(112.39,56.01) 112.27,56.13 FB7.2
  BOTTOM w0.305: U2.39 113.14,55.31 112.45,56.01 v1(112.39,56.01)
N19083446: length 3.1
  TOP w0.508: v1(116.1,56.46) 115.85,56.72 FB9.2
  BOTTOM w0.305: U2.45 116.15,55.28 116.11,55.31 116.11,55.75 116.15,55.79 116.15,56.42 v1(116.1,56.46)
N19083508: length 1.9
  TOP w0.305: v1(117.18,55.85) 116.89,56.13 v1(116.87,56.13)
  BOTTOM w0.305: v1(116.87,56.13) 116.89,56.13 v1(117.18,55.85) 117.15,55.81 117.15,55.79 117.18,55.75 117.18,55.31 117.15,55.28 U2.47
N19083566: length 2.7
  TOP w0.508: C56.2 v1(108.48,48.51) FB3.2
  BOTTOM w0.305: U2.21 v1(107.82,48.52)
N19083568: length 2.7
  TOP w0.508: FB5.2 v1(107.89,46.51) 107.9,46.51 v1(108.53,46.51) 108.97,46.51 C55.2
  BOTTOM w0.305: U2.17 v1(107.89,46.51)
N19083616: length 2.2
  TOP w0.762: v1(118.62,46.25) 118.64,46.23 FB11.2
  BOTTOM w0.305: v1(118.62,45.62) v1(118.62,46.25) 118.47,46.4 U2.64
N19083618: length 1.1
  BOTTOM w0.305: v1(119.38,51.58) 118.94,52.02 U2.53
  vias: v1(119.46,50.65) v1(119.74,51.18)
N19083707: length 2.9
  TOP w0.508: C57.2 108.93,51.37 v1(107.79,51.37)
  BOTTOM w0.305: v1(107.79,51.37) 108.37,51.37 v1(108.38,51.36) 108.72,51.02 U2.26
N19086842: length 7.1
  BOTTOM w0.229: U2.16 110.14,44.81 110.2,44.75 110.2,44.43 109.94,44.17 107.16,44.17 106.58,43.59 106.58,42.9 R38.1 106.35,42.62 R36.1
N19086844: length 7.1
  BOTTOM w0.229: U2.15 110.64,44.81 110.58,44.75 110.58,44.27 110.1,43.79 107.32,43.79 106.96,43.43 106.96,42.82 R37.1 107.14,41.88 R31.1
N19234861: length 2.4
  BOTTOM w0.305: v1(113.54,56.72) 113.66,56.72 114.64,55.74 U2.42
N174889162:
  vias: v1(137.31,33.32)
N174890102:
  vias: v1(137.29,30.68)
N176074941: length 0.8
  TOP w0.305: 117.47,54.1 118.24,54.1
N176076570: length 0.9
  BOTTOM w0.305: C30.2 R21.1

## Copper pours and planes (outline as drawn)
1.8V_USB on TOP: 41.43,50.14 41.43,48.16 44.53,48.16 44.53,50.93 43.26,50.93 42.47,50.14
1.8V_USB on L6_PWR_SIG: 20.35,56.34 20.35,45.21 41.88,45.21 46.58,49.91 50.77,49.91 55.63,54.76 55.63,66.8 30.96,66.8 30.96,63.12 30.33,62.48 26.49,62.48
1.8VCLK on TOP: 76.81,43.94 76.81,39.75 78.49,38.07 81.71,38.07 83.54,39.9 83.54,43.56 81.89,45.21 78.08,45.21
1.8VCLK on L6_PWR_SIG: 77.95,39.34 77.95,46.86 80.62,49.53 80.62,60.45 86.79,60.45 87.83,59.41 87.83,47.24 84.56,43.97 84.56,39.34
3.3V_USB on TOP: 24.71,56.67 24.71,52.55 26.14,52.55 26.14,56.67
3.3V_USB on TOP: 47.88,61.9 47.88,60.81 48.74,60.81 48.74,59.23 49.81,59.23 49.81,61.9
3.3V_USB on BOTTOM: 47.88,61.9 47.88,59.23 49.81,59.23 49.81,61.9
3.3V_USB on L6_PWR_SIG: 35.66,49.02 35.66,50.93 34.87,51.71 24.76,51.71 24.76,56.46 25.45,57.15 29.41,57.15 29.41,55.78 35.74,55.78 35.74,56.92 35.41,57.25 35.41,59.69 42.34,59.69 42.34,58.01 41.63,57.3 41.63,56.16 41.78,56.01 45.19,56.01 47.62,58.45 47.62,61.82 47.73,61.93 51.44,61.93 51.44,55.52 49.25,53.34 45.69,53.34 39.47,47.12 37.57,47.12
5.0V_SOURCE on BOTTOM (solid shape): 30.17,63.36 25.65,63.36 25.65,67.17 30.17,67.17
5.0V_SOURCE on TOP: 13.34,63.47 13.34,68.43 30.61,68.43 30.61,63.22 20.52,63.22 18.34,61.04 15.77,61.04
5.0V_SOURCE on BOTTOM: 13.34,68.43 30.61,68.43 30.61,63.22 20.52,63.22 18.34,61.04 15.77,61.04 13.34,63.47
5.0V_SOURCE on L3_PWR: 13.34,63.78 13.34,68.07 30.23,68.07 30.23,63.68 29.59,63.04 26.21,63.04 22.22,59.05 18.06,59.05
5.0V_SOURCE on L6_PWR_SIG: 13.34,62.59 13.34,68.07 30.23,68.07 30.23,63.68 29.79,63.25 26.26,63.25 22.07,59.05 16.87,59.05
+0.9V_VDDA on TOP: 97,29.34 97,26.92 99.52,26.92 99.52,29.34
+0.9V_VDDA on BOTTOM: 96.88,26.87 96.88,29.36 99.72,29.36 99.72,26.87
+0.9V_VDDA on L6_PWR_SIG: 28.3,29.24 28.7,29.24 29.59,28.35 29.59,27.28 29.84,27.03 30.58,27.03 30.58,23.62 28.68,21.72 28.68,17.91 32.49,14.1 73.76,14.1 81.89,22.23 92.62,22.23 95.86,25.91 95.83,29.34 99.54,29.34 99.54,22.73 94.46,17.65 83.67,17.65 75.69,9.68 29.03,9.68 23.98,14.73 23.98,22.48 25.5,24 28.73,24 29.46,24.74 29.46,25.93 29.06,26.34 28.22,26.34 28.19,26.37 28.19,29.13
+0.9V_VDDCLK on TOP: 42.95,42.39 46.96,42.39 46.96,40.77 42.95,40.77
+0.9V_VDDCLK on BOTTOM: 43,40.77 46.89,40.77 46.89,42.39 43,42.39
+0.9V_VDDCLK on L6_PWR_SIG: 30.45,27.15 30.45,27.53 31.24,28.32 31.24,31.14 34.85,34.75 40.84,34.75 46.96,40.87 46.96,42.37 42.55,42.37 42.55,41.43 39.55,38.43 33.5,38.43 29.67,34.59 29.67,27.46 29.97,27.15
+0.9V_VDDL1 on TOP: 47.6,40.82 51.41,40.82 51.41,42.44 47.6,42.44
+0.9V_VDDL1 on BOTTOM: 47.65,40.77 51.94,40.77 51.94,42.44 47.65,42.44
+0.9V_VDDL1 on L3_PWR: 30.73,27.18 31.01,27.18 31.01,28.47 31.11,28.58 31.11,32.11 32.36,33.35 32.36,35.79 35.26,38.68 46.46,38.68 48.54,40.77 51.54,40.77 51.54,42.67 46.48,42.67 44.4,40.59 33.2,40.59 29.54,36.93 29.54,29.49 30.38,27.53
+0.9V_VDDL2 on TOP: 40.87,42.21 40.87,40.74 37.13,40.74 37.13,42.21
+0.9V_VDDL2 on BOTTOM: 37.19,40.77 37.19,42.19 42.01,42.19 42.01,40.77
+0.9V_VDDL2 on L3_PWR: 28.83,27.18 28.83,28.3 25.32,31.8 25.32,37.54 32.79,45.01 35.15,45.01 36.32,43.84 41.53,43.84 41.53,41.55 40.92,40.94 33.05,40.94 28.19,36.09 28.19,31.6 28.87,30.92 29.51,28.73 29.51,27.18
+0.9V_VDDPLL on TOP: 60.05,29.84 57.15,29.84 57.15,30.61 57.02,30.73 55.73,30.73 55.73,32.51 60.05,32.51
+0.9V_VDDPLL on BOTTOM: 57.18,29.92 60.02,29.92 60.02,32.42 56.71,32.42 56.59,32.54 55.75,32.54 55.75,30.71 56.39,30.71
+0.9V_VDDPLL on L6_PWR_SIG: 30.63,26.03 30.63,24.66 31.29,24 37.21,24 40.01,26.8 53.57,26.8 56.62,29.84 60.07,29.84 60.07,32.82 54,32.82 51.16,29.97 39.37,29.97 36.45,27.05 31.65,27.05
+0.9V_VDDT on TOP: 65.51,41.81 65.51,40.64 66.01,40.13 69.19,40.13 69.19,41.81
+0.9V_VDDT on BOTTOM: 65.51,41.78 65.51,40.39 69.44,40.39 69.44,41.78
+0.9V_VDDT on L3_PWR: 34.09,28.27 34.09,31.12 37.77,34.8 51.92,34.8 53.67,36.55 59.49,36.55 65.05,42.11 69.32,42.11 69.32,40.49 68.45,39.62 66.78,39.62 59.66,32.51 54.08,32.51 53.11,31.55 37.03,31.55 35.05,29.57 35.05,27.94 34.42,27.94
+0.9V_VDDTX on TOP: 75.95,29.18 75.95,26.8 78.56,26.8 78.56,29.18
+0.9V_VDDTX on BOTTOM: 74.63,28.24 74.63,26.75 78.56,26.75 78.56,29.21 75.69,29.21 75.69,28.27 75.67,28.24
+0.9V_VDDTX on L6_PWR_SIG: 32.08,23.62 32.08,20.85 34.26,18.67 70.71,18.67 78.84,26.8 78.84,29.34 76.3,29.34 68.71,21.74 40.64,21.74 39.6,20.7 35.15,20.7 32.96,22.9 32.96,23.43 32.77,23.62
+1.8V_VDDA on TOP: 92.51,29.18 92.51,26.9 95.12,26.9 95.12,29.18
+1.8V_VDDA on BOTTOM: 92.51,29.18 92.51,26.9 95.25,26.9 95.25,29.18
+1.8V_VDDA on L3_PWR: 28.57,28.35 28.57,26.67 24.49,26.67 19.68,22.23 19.68,13.33 25.4,7.62 76.81,7.62 92.18,22.99 92.18,30.23 96.62,30.23 96.62,21.08 76.94,1.4 24,1.4 13.94,11.46 13.94,23.11 21.26,30.43 25.45,30.43 27.43,28.45 28.47,28.45
+1.8V_VDDAPLL on TOP: 84.38,29.31 84.38,26.72 87.07,26.72 87.07,29.31
+1.8V_VDDAPLL on BOTTOM: 84.41,29.31 84.41,26.72 87.05,26.72 87.05,29.31
+1.8V_VDDAPLL on L3_PWR: 27.41,21.95 27.41,18.54 32.11,13.84 74.78,13.84 87.1,26.16 87.1,29.72 84.94,29.72 73.13,17.91 33.76,17.91 30.23,21.44 30.23,23.62 29.08,23.62
+1.8V_VDDIO on TOP: 56.26,42.44 52.5,42.44 52.5,41.05 56.26,41.05
+1.8V_VDDIO on BOTTOM: 52.55,42.44 56.24,42.44 56.24,41.02 52.55,41.02
+1.8V_VDDIO on L6_PWR_SIG: 32.97,28.35 32.97,27.86 33.15,27.69 36.58,27.69 39.5,30.61 49.76,30.61 56.26,37.11 56.26,42.55 51.54,42.55 42.77,33.78 37.74,33.78 34.92,30.96 34.92,30.3
+1.8V_VDDOUTA on TOP: 101.27,29.08 101.27,26.77 103.89,26.77 103.89,29.08
+1.8V_VDDOUTA on BOTTOM: 18.49,28.55 18.49,27.74 21.51,27.74 21.51,28.55
+1.8V_VDDOUTA on BOTTOM: 101.27,29.11 101.27,26.75 103.89,26.75 103.89,29.11
+1.8V_VDDOUTA on L6_PWR_SIG: 16.61,9.02 16.61,35.99 18.41,37.8 21.11,37.8 23.09,35.81 23.09,13.33 27.38,9.04 76.33,9.04 83.29,16 95.35,16 100.94,21.59 100.94,29.21 105.44,29.21 105.44,18.72 97.64,10.92 85.19,10.92 75.41,1.14 24.49,1.14
+1.8V_VDDR on TOP: 61.06,31.35 61.06,29.84 61.44,29.46 61.44,27.94 62.33,27.94 62.46,28.07 62.46,29.59 62.71,29.84 64.49,29.84 64.49,31.35
+1.8V_VDDR on BOTTOM: 61.06,31.32 61.06,29.84 61.44,29.46 61.44,27.94 62.46,27.94 62.46,29.59 62.71,29.84 64.16,29.84 64.39,30.07 64.39,31.32
+1.8V_VDDR on L3_PWR: 35.43,29.24 35.43,27.43 61.77,27.43 64.49,30.15 64.49,31.75 55.85,31.75 55.14,31.04 37.24,31.04
+1.8V_VDDS on TOP: 70.46,29.46 70.46,28.07 70.21,27.81 69.06,27.81 69.06,26.8 72.75,26.8 73.25,27.3 73.25,29.21 73,29.46
+1.8V_VDDS on BOTTOM: 70.33,29.46 70.33,28.19 69.95,27.81 69.19,27.81 69.19,26.8 73.15,26.8 73.15,29.46
+1.8V_VDDS on L6_PWR_SIG: 33.76,23.62 33.76,23.11 35.53,21.34 39.09,21.34 40.49,22.73 68.43,22.73 73.13,27.43 73.13,29.34 70.59,29.34 67.11,25.86 39.7,25.86 37.47,23.62
+1.8V_VDDTX on TOP: 80.19,29.31 80.19,26.85 83.06,26.85 83.06,29.31
+1.8V_VDDTX on BOTTOM: 80.21,26.8 80.21,29.34 83.06,29.34 83.06,26.8
+1.8V_VDDTX on L6_PWR_SIG: 31.8,23.62 31.8,22.15 31.6,21.95 31.6,20.57 34.26,17.91 71.22,17.91 80.11,26.8 80.11,29.26 83.92,29.26 83.92,25.53 73.36,14.96 34.05,14.96 33.1,15.37 29.31,19.15 29.31,21.95 30.99,23.62
+1.8V_VDDVCO on TOP: 88.49,29.18 88.49,26.82 91.08,26.82 91.08,29.18
+1.8V_VDDVCO on BOTTOM: 88.49,29.18 88.49,26.8 91.08,26.8 91.08,29.18
+1.8V_VDDVCO on L3_PWR: 22.2,12.95 22.2,22.2 25.78,25.78 27.05,25.78 27.56,26.29 30.48,26.29 30.48,24.13 29.08,24.13 26.77,21.82 26.77,17.91 31.47,13.21 75.41,13.21 87.73,25.53 87.73,29.46 91.54,29.46 91.54,23.62 76.73,8.81 26.34,8.81
+3.3VCLK on TOP: 106.68,46.23 106.68,47.62 105.28,47.62 105.28,46.23
+3.3VCLK on TOP: 101.8,48.62 101.8,46.43 103.68,46.43 103.68,49.91 100.53,49.91 100.48,49.86 100.48,48.87 101.55,48.87
+3.3VCLK on TOP: 106.6,50.9 106.6,52.3 105.21,52.3 105.21,50.9
+3.3VCLK on TOP: 119.9,49.28 120.89,48.3 121.87,49.28 120.89,50.27
+3.3VCLK on TOP: 119.76,45.47 119.76,44.07 121.16,44.07 121.16,45.47
+3.3VCLK on TOP: 109.09,55.5 109.09,56.9 107.7,56.9 107.7,55.5
+3.3VCLK on TOP: 111.12,62.23 111.12,63.63 109.73,63.63 109.73,62.23
+3.3VCLK on L3_PWR: 138.53,48.9 132.82,43.18 115.67,43.18 115.67,56.64 109.09,56.64 109.09,45.85 102.74,45.85 99.16,49.43 99.16,66.17 138.53,66.17
+3.3VIO on TOP: 49.53,65.43 49.53,64.39 46.2,64.39 46.2,65.43
+3.3VIO on BOTTOM: 46.2,65.51 46.2,64.36 49.23,64.36 49.23,65.51
+5VIN on TOP: 61.47,58.24 61.47,62.28 62.51,63.32 64.19,63.32 64.19,60.55 62.92,59.28 62.92,58.24
+5VIN on TOP: 42.98,64.72 42.98,67.41 45.67,67.41 45.67,64.72
+5VIN on TOP: 94.59,56.24 98.2,56.24 98.2,54.69 95.5,54.69 95.5,52.32 93.98,52.32 93.98,52.58 94.44,53.04 94.44,56.08
+5VIN on TOP: 33.38,66.73 33.38,64.41 38.71,64.41 38.71,65.2 37.26,65.2 37.06,65.41 37.06,66.73
+5VIN on BOTTOM: 38.71,64.44 38.71,65.07 37.06,66.73 33.76,66.73 33.76,64.44
+5VIN on BOTTOM: 96.52,56.26 96.52,54.56 95.76,54.56 95.53,54.33 95.53,52.2 92.81,52.2 92.81,54.46 94.61,56.26
+5VIN on BOTTOM: 81.81,63.8 81.81,64.95 87.1,64.95 87.1,63.8
+5VIN on BOTTOM: 42.8,67.41 42.8,62.74 43.69,62.74 43.69,64.36 44.07,64.74 45.67,64.74 45.67,67.41
+5VIN on L3_PWR: 87.73,40.77 86.46,42.04 86.46,47.75 83.18,51.03 53.54,51.03 50.39,47.88 47.73,47.88 47.73,50.29 54.71,57.28 54.71,60.45 54.08,61.09 35.86,61.09 33.91,63.04 33.91,66.8 69.47,66.8 73.28,62.99 76.07,62.99 79.25,66.17 88.37,66.17 96.62,57.91 96.62,40.77
-1.8V_VEE on TOP: 35.03,42.62 31.62,42.62 31.62,40.97 35.03,40.97
-1.8V_VEE on BOTTOM: 35.03,42.55 31.6,42.55 31.6,41.02 33.76,41.02 33.88,40.89 33.88,39.88 35.03,39.88 35.03,41.02
-1.8V_VEE on L6_PWR_SIG: 24.82,38.15 29.34,42.67 35.08,42.67 35.08,39.45 33.07,39.45 28.17,34.54 28.17,32 29.44,30.73 29.44,29.69 29.34,29.59 28.3,29.59 28.04,29.34 28.04,26.16 29.08,26.16 29.46,25.78 29.46,24.77 28.93,24.77 28.6,24.43 26.26,24.43 24.82,25.88
GND on TOP (solid shape): 29.75,16.72 30.46,16.72 30.46,15.26 30.1,15.26 30.1,16.31 29.04,16.31 29.04,15.26 28.68,15.26 28.68,16.72 29.39,16.72 29.39,17.81 29.75,17.81
GND on TOP, L2_GND: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 1 cut-out
GND on BOTTOM: 92.25,31.17 92.25,29.64 95.4,29.64 95.4,31.17
GND on BOTTOM: 81.86,59.74 81.86,58.29 84,58.29 84,59.74
GND on BOTTOM: 101.02,31.19 101.02,29.59 103.91,29.59 103.91,31.19
GND on BOTTOM: 61.52,33.22 61.52,31.88 64.82,31.88 64.82,33.22
GND on BOTTOM: 57,34.42 57,32.97 59.79,32.97 59.79,34.42
GND on BOTTOM: 70.23,31.37 70.23,29.84 73.38,29.84 73.38,31.37
GND on BOTTOM: 59.23,45.06 59.23,43.71 62.59,43.71 62.59,45.06
GND on BOTTOM: 47.42,44.27 47.42,42.9 51.99,42.9 51.99,44.27
GND on BOTTOM: 84.3,31.24 84.3,29.84 87.02,29.84 87.02,31.24
GND on BOTTOM: 53.01,44.42 53.01,43.08 55.98,43.08 55.98,44.42
GND on BOTTOM: 65.43,43.64 65.43,42.29 69.34,42.29 69.34,43.64
GND on BOTTOM: 96.72,31.27 96.72,29.77 99.75,29.77 99.75,31.27
GND on BOTTOM: 43,44.32 43,42.9 46.96,42.9 46.96,44.32
GND on BOTTOM: 88.47,31.12 88.47,29.72 91.16,29.72 91.16,31.12
GND on BOTTOM: 66.22,32.77 66.22,31.34 68.96,31.34 68.96,32.77
GND on BOTTOM: 75.87,31.09 75.87,29.69 78.82,29.69 78.82,31.09
GND on BOTTOM: 37.92,44.12 37.92,42.65 42.14,42.65 42.14,44.12
GND on BOTTOM: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 6 cut-outs
GND on BOTTOM: 35.48,42.67 35.48,39.85 36.86,39.85 36.86,42.67
GND on BOTTOM: 79.93,31.37 79.93,29.87 82.96,29.87 82.96,31.37
GND on L3_PWR: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 7 cut-outs
GND on L4_SIG: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 12 cut-outs
GND on L5_GND: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 1 cut-out
GND on L6_PWR_SIG: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 1 cut-out
GND on L7_GND: 0.38,0.38 0.38,68.2 157.1,68.2 157.1,0.38 ; 1 cut-out
VDD on TOP: 66.14,30.84 66.14,29.59 65.89,29.34 64.49,29.34 64.49,28.58 66.14,28.58 66.14,28.24 68.86,28.24 68.86,30.84
VDD on BOTTOM: 64.34,28.47 64.34,29.51 65.94,29.51 66.14,29.72 66.14,30.84 68.86,30.84 68.86,28.24 66.83,28.24 66.83,28.47
VDD on L3_PWR: 31.37,21.56 31.37,25.12 32.97,26.72 32.97,27.53 33.05,27.61 34.11,27.61 34.92,26.8 62.33,26.8 66.27,30.73 69.32,30.73 69.32,22.35 65.51,18.54 34.39,18.54
VDDE on BOTTOM: 47.75,37.29 47.75,35.92 49.5,35.92 49.5,37.29
VDDE on L3_PWR: 31.34,26.29 31.34,28.37 31.78,28.8 31.78,31.27 33.3,32.79 33.3,35.26 36.22,38.18 49.63,38.18 49.63,35.31 37.74,35.31 33.22,30.78 33.22,28.58 32.74,28.58 32.74,27.15 31.88,26.29
VDDE_09 on TOP: 50.16,36.07 50.16,37.29 52.53,37.29 52.53,36.07
VDDE_09 on TOP: 58.6,43.18 58.6,41.22 62.08,41.22 62.08,43.18
VDDE_09 on BOTTOM: 59.51,43.18 59.51,41.78 62.33,41.78 62.33,43.18
VDDE_09 on BOTTOM: 50.37,37.29 50.37,35.97 52.25,35.97 52.25,37.29
VDDE_09 on L3_PWR: 50.39,35.69 50.39,38.86 54.84,43.31 62.33,43.31 62.33,41.27 61.19,40.13 56.36,40.13 51.92,35.69
VDDOUT18 on BOTTOM: 22.33,28.55 22.33,27.76 25.68,27.76 26.14,27.3 26.52,27.3 26.85,26.97 26.87,26.97 27.08,27.18 27.69,27.18 27.84,27.33 27.84,28.3 27.66,28.47 26.97,28.47 26.82,28.63 26.8,28.63 26.47,28.3 26.34,28.3 25.6,29.03 24.74,29.03 24.26,28.55
+1P8V on TOP, BOTTOM: 53.21,44.96 53.21,46.36 54.86,46.36 54.86,44.96
+1P8V on BOTTOM: 80.62,33.15 80.62,35.21 84.45,35.2 85.06,35.81 85.06,40.01 86.72,40.01 86.72,35.43 86.96,35.19 102.97,35.16 102.97,33.15
+1P8V on BOTTOM: 70.54,32.92 70.54,31.88 72.14,31.88 72.14,32.92
+1P8V on BOTTOM: 63.7,35.15 63.7,33.58 64.77,33.58 64.77,35.15
+1P8V on L3_PWR: 63.6,32.49 63.6,35.26 68.25,35.26 70.21,37.21 70.21,42.98 68.76,44.42 53.19,44.42 53.19,46.23 54.36,47.4 71.58,47.4 73.76,45.21 73.76,37.62 76.12,35.26 82.65,35.26 82.65,33.02 80.87,33.02 79.73,31.88 65.35,31.88 64.74,32.49
Net_1 on L6_PWR_SIG: 87.1,40.77 87.1,43.94 89,45.85 89,59.18 86.72,61.47 79.1,61.47 77.95,60.33 77.95,57.53 76.81,57.53 75.67,56.39 75.67,55.63 73,55.63 73,61.21 78.36,66.57 89.23,66.57 94.72,61.09 94.72,40.77
U37_BYPASS on TOP: 67.28,47.88 70.61,47.88 71.04,48.31 71.04,52.25 70.15,53.14 68.96,53.14 68.96,54.61 71.09,54.61 72.36,53.34 72.36,47.5 71.55,46.69 65.81,46.69 65.76,46.74 65.76,48.26 67.16,48.26 67.16,48.01
VAR on TOP: 85.88,42.24 85.88,40.97 87.38,40.97 87.38,42.24
VAR on TOP: 77.52,58.7 77.52,62.38 78.51,63.37 81.41,63.37 81.41,61.67 81.61,61.47 88.47,61.47 88.47,60.1 81.61,60.1 81.41,59.89 81.41,57.81 79.76,57.81 79.76,58.7
VAR on BOTTOM: 84.43,40.97 84.43,52.7 87.73,56.01 87.73,59.44 85.95,61.21 85.95,62.71 87.1,62.71 87.1,62.1 87.6,61.59 90.27,61.59 90.27,54.48 87.35,51.56 87.35,40.97
VAR on BOTTOM: 73.96,57.43 73.96,58.6 77.01,61.65 81.13,61.65 81.13,60.4 79.48,60.4 79.48,58.62 79.43,58.57 75.95,58.57 75.56,58.19 75.56,57.43
VDIG on TOP: 65.58,61.62 65.58,60.81 66.09,60.3 68.05,60.3 68.55,59.79 68.55,56.26 71.42,56.26 71.42,61.62
VDIG on BOTTOM: 68.81,56.29 68.81,61.16 71.42,61.16 71.42,56.29
VDIG on L6_PWR_SIG: 66.52,60.33 66.52,66.17 71.86,66.17 71.86,56.01 68.43,56.01 68.43,59.82 67.92,60.33
N16791900 on TOP: 27.74,52.3 27.74,54.23 29.16,54.23 29.16,53.37 29.39,53.14 31.5,53.14 31.5,52.3
N16791904 on TOP: 27.76,54.97 27.76,56.67 29.21,56.67 29.21,56.24 31.29,56.24 31.5,56.03 31.5,55.63 31.32,55.45 29.21,55.45 29.21,54.97
N17771557 on TOP: 55.7,46.94 55.7,45.16 57.07,45.16 57.07,46.94
N17771557 on TOP: 94.72,33.15 94.72,34.29 93.88,35.13 75.64,35.13 72.97,37.8 72.97,43.59 72.62,43.94 69.95,43.94 69.95,46.13 74.37,46.13 75.41,45.09 75.41,38.86 77.44,36.84 94.35,36.84 96.47,34.72 96.47,33.15
N17771557 on BOTTOM: 59.46,36.42 59.46,34.72 60.91,34.72 60.91,36.42
N17771557 on BOTTOM: 49.12,47.96 49.12,46.69 43.23,46.69 42.14,45.59 42.14,44.58 40.61,44.58 40.61,45.97 42.6,47.96
N17771557 on L6_PWR_SIG: 56.92,34.42 56.92,44.27 56.62,44.58 47.52,44.58 47.52,47.42 47.98,47.88 61.57,47.88 63.32,46.13 72.16,46.13 72.16,43.94 63.6,43.94 62.97,43.31 62.97,42.04 61.06,40.13 61.06,34.42
N17785180 on TOP: 53.06,49.1 53.06,49.4 53.75,49.4 53.75,49.78 55.83,49.78 56.74,48.87 56.74,47.88 54.28,47.88
N17785180 on L3_PWR: 35.56,45.26 35.56,47.12 50.27,47.12 53.44,50.29 56.62,50.29 56.62,47.88 54.2,47.88 50.55,44.22 36.6,44.22
N17787232 on TOP: 103.78,52.48 103.78,53.47 103.64,53.61 103.63,53.59 101.22,53.59 101.22,56.44 98.81,56.44 98.81,54.86 99.82,54.86 99.82,52.7 100.05,52.48
N17787232 on BOTTOM: 98.7,56.41 98.7,54.61 99.77,54.61 99.77,53.62 100.96,53.62 101.85,52.73 103.78,52.73 103.78,53.34 100.71,56.41
N18303715 on TOP: 76.23,31.62 76.23,34.04 77.88,34.04 77.88,31.62
N18304202 on TOP: 87.88,41.02 87.88,42.6 88.09,42.8 93.37,42.8 93.37,41.02
N18304202 on BOTTOM: 87.73,42.44 87.73,41.02 93.37,41.02 93.37,42.8 88.09,42.8
N18304307 on TOP: 91.77,38.99 91.77,37.82 91.29,37.34 89.1,37.34 89.1,38.71 89.38,38.99
N18304307 on BOTTOM: 89.15,35.69 89.15,39.12 91.54,39.12 91.54,36.96 92.1,36.96 92.1,35.69
N18314120 on TOP: 73.76,46.84 73.76,48.51 77.06,48.51 77.44,48.9 77.44,54.48 79.68,54.48 79.68,55.47 79.71,55.5 80.8,55.5 80.8,53.95 80.24,53.39 80.24,48.77 78.31,46.84
N18314120 on BOTTOM: 79.86,48.39 79.86,52.83 81.13,54.1 81.13,55.5 79.86,55.5 79.86,54.86 79.45,54.46 77.44,54.46 77.44,48.39
N18315084 on L4_SIG: 77.62,64.11 77.62,63.09 85.65,63.09 85.65,64.11
N18517211 on TOP: 56.49,55.37 56.49,57.18 57.73,57.18 58.52,56.39 58.52,49.53 59.66,48.39 63.98,48.39 63.98,40.13 68.1,36.02 68.1,33.3 66.37,33.3 66.37,35.31 62.59,39.09 62.59,46.61 61.9,47.29 58.72,47.29 57.19,48.83 57.19,54.67
N18526029 on TOP: 65.28,53.16 65.28,53.49 64.31,53.49 64.31,54.53 65.74,54.53 65.74,55.93 66.55,55.93 66.88,56.26 66.88,57.58 68,57.58 68,53.77 67.39,53.16
N18526029 on BOTTOM: 70.54,53.24 70.54,55.07 65.74,55.07 65.74,53.24
N18526106 on TOP: 61.21,53.01 61.21,55.12 59.46,55.12 59.46,57.58 62.69,57.58 62.69,54.76 62.87,54.58 63.6,54.58 63.6,53.01
N18555017 on TOP: 26.9,60.88 26.9,62.28 30.71,62.28 31.09,62.66 31.09,63.55 35.03,63.55 35.03,62.15 33.76,60.88
N18555017 on BOTTOM: 26.9,60.88 26.9,62.28 30.71,62.28 31.09,62.66 31.09,63.55 33.66,63.55 33.66,61.87 32.66,60.88
N18721425 on TOP: 97.03,31.78 97.03,34.47 98.76,34.47 98.76,31.78
N18721471 on TOP: 57.28,34.9 57.28,36.22 58.85,36.22 58.85,34.9
N18721471 on BOTTOM: 57.3,34.93 57.3,36.2 58.85,36.2 58.85,34.93
N18729042 on TOP: 61.44,35 61.44,33.73 63.04,33.73 63.04,35
N18729042 on BOTTOM: 61.44,35 61.44,33.73 62.97,33.73 62.97,35
N18737961 on TOP: 57.89,46.74 57.89,45.47 61.19,45.47 61.19,46.74
N18774590 on TOP: 69.01,45.47 69.01,44.04 65.61,44.04 65.61,45.47
N19080738 on TOP: 123.47,63.7 123.47,66.65 126.85,66.65 127.38,66.12 132.92,66.12 132.92,63.7
N19083364 on TOP: 109.75,56.31 109.75,54.43 111.99,54.43 111.99,55.63 111.3,56.31
N19083364 on L3_PWR: 109.85,56.01 109.85,43.31 114.45,43.31 114.45,56.01
N19083508 on TOP: 111.89,57.66 111.89,63.07 112.9,63.07 112.9,58.93 116.56,58.93 118.24,57.25 118.24,55.37 117.45,55.37 116.71,56.11 116.71,56.95 116,57.66
N19083618 on TOP: 119.96,50.44 119.96,51.31 119.51,51.77 118.47,51.77 117.91,51.21 117.91,49.89 119.41,49.89

## Text on the board
BOTTOM: LAYER 6 (BOTTOM SIDE)
Board Geometry/Soldermask Bottom: SOLDERMASK BOTTOM
Ref Des/Silkscreen Bottom: SILKSCREEN BOTTOM
User.Comments: C448 | C30 | R21 | R329 | R225 | C392 | C393 | C432 | R310 | R304 | R314 | R301 | R306 | R243 | R312 | R311 | R333 | R307 | R332 | C420 | R308 | R218 | R219 | R309 | C256 | C255 | C122 | C251 | C250 | R300 | R302 | R224 | C391 | C389 | C388 | C390 | C119 | A1 | B1 | C1 | D1 | E1 | F1 | G1 | H1 | J1 | K1 | A40 | B40 | C40 | D40 | E40 | F40 | G40 | H40 | J40 | K40 | A6 | A11 | A16 | A21 | A26 | A31 | A36 | K6 | K21 | K11 | K16 | K26 | K31 | K36 | * | C249 | C254 | C258 | C117 | C120 | C446 | C125 | C353 | C169 | C107 | R103 | R104 | C374 | C127 | C167 | C345 | C137 | C111 | C343 | C170 | C357 | C347 | C160 | C28 | R12 | R250 | C159 | R187 | C447 | C165 | C177 | C149 | C377 | C153 | C248 | C145 | C112 | C156 | C136 | C133 | C132 | C141 | R110 | C223 | C174 | R5 | R4 | C171 | C118 | C375 | C161 | C157 | C151 | C350 | R80 | R82 | R83 | C247 | C260 | C140 | C348 | C349 | C176 | C164 | C148 | C108 | C152 | C179 | U21 | 1 | U35 | U30 | L5 | R42 | R107 | R41 | R106 | C36 | C35 | R37 | C318 | R38 | R30 | R34 | R32 | C394 | C429 | R221 | C427 | C364 | L9 | L10 | C330 | C332 | C327 | R40 | R39 | R29 | R31 | R35 | R36 | C292 | C291 | R9 | R10 | R244 | C272 | C271 | C283 | R33 | C282 | C295 | R227 | R228 | C294 | C305 | C304 | C378 | R226 | C237 | C236 | C309 | C308 | C27 | C37 | C419 | C259 | R222 | C328 | C331 | (8 PL) | ALPHANOVATECH # | PUSH PIN | 2 EA | NR35-25B-IP3N | J20 | Y1 | Q4 | J16 | R79 | R84 | R81 | R62 | R59 | R61 | R60 | C29 | C32 | R22 | R23 | C42 | C43 | C48 | R55 | R57 | C47 | R52 | R44 | R11 | C49 | C44 | C50 | C45 | U2 | T3 | R317 | C175 | C356 | R319 | R318 | R126 | C342 | R315 | C70 | U4 | R140 | C221 | C321 | C322 | R69 | FB17 | R67 | C402 | R288 | R290 | C352 | C401 | R289 | R66 | R65 | C404 | R291 | C397 | R64 | Y2 | C400 | R27 | R26 | R25 | R24 | R47 | R53 | R46 | R45 | R50 | R51 | R56 | R58 | R49 | R43 | R54 | R48 | C51 | C46 | C417 | C418 | C386 | C387 | C376 | C242 | C358 | C346 | R258 | C241 | C444 | C441 | C445 | C245 | C244 | R125 | C72 | C269 | C71 | C268 | C263 | C262 | C225 | R63 | C76 | C77 | C366 | R296 | C128 | C123 | C126 | C275 | C274 | C344 | C351 | C403 | C398 | C78 | C79 | U29 | TEXAS INSTRUMENTS, INC. | DAC38RF8xEVM PCB REV F | TOP VIEW | BOTTOM VIEW
TOP: LAYER 1 (TOP SIDE)
Board Geometry/Soldermask Top: SOLDERMASK TOP
Ref Des/Silkscreen Top: UL94V-0 | +5V IN | DAC38RF80EVM | DAC38RF82EVM | DAC38RF86EVM | PCB REV F | DAC38RF89EVM | DAC38RF87EVM | SILKSCREEN TOP
L2_GND: LAYER 2 - GND
L3_PWR: LAYER 3 - POWER
L4_SIG: LAYER 4 - SIGNAL
L5_GND: LAYER 5 - GROUND
L6_PWR_SIG: LAYER 6 - POWER/SIGNAL
L7_GND: LAYER 7 - GROUND
DISPLAY_TOP: PASTEMASK TOP
PAGE_OUTLINE: PASTEMASK BOTTOM
User.6: SOLDERMASK TOP SOCKET BOARD
User.7: PASTEMASK TOP SOCKET BOARD
User.11: 0.25oz / Plate to 0.5oz min Layer 6 | R-1775V | R-1650V | Core 0.008" | Copper Foil | Core 0.012" | Pre-preg 0.0046" | 0.5oz / 0.5oz Layer 5 & 6 | (material) | LAYER 5 | LAYER 6
User.12: 03-23-17 | 3. MARK BOARD'S SILKSCREEN AND ESD BAG WITH THE APPROPREATE EVM PART NUMBER. | 4. IPC-A-610 / ACCEPTABILITY OF ELECTRONIC ASSEMBLIES, CLASS 2, CURRENT REVISION. | 5. SEE HEATSINK SPEC DRAWING FOR INSTALLATION REFERENCE.
User.21: FIGURE | SIZE | 6.0 | 8.0 | 10.0 | 12.0 | 38.0 | 40.0 | 55.0 | 62.0 | 67.0 | 106.0 | 120.0 | 125.0 | 140.0 | 35.43 | 50.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | NON-PLATED | QTY | 109 | 8 | 14 | 2720 | 108 | 528 | 24 | 5 | 2 | 7 | 20 | 4 | 1
